## drivers/ras/phytium/Kconfig
```kconfig
menuconfig PHYTIUM_S2500_DFX
	bool "Phytium S2500 RAS/DFX features"
	help
	  Phytium S2500 RAS registers used for DFX.
```
